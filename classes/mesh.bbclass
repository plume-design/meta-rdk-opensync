FEATURE_PACKAGES_meshwifi = "packagegroup-meshwifi"
