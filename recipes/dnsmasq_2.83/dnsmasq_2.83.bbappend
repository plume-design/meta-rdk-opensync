FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://300-vendor-class-dhcp-lease-file.patch"
